# Repository spacecraft-design-lab-2019/Solar-Panel-plus-Y

## KiCad design SolarCell+Y.kicad_pcb

Board: 6 copper layers, 50.0 x 50.0 mm, 67 parts (0 on the bottom side), 34 nets.

Parts:
C1: 1uF; C_0402_1005Metric
C2: 1.0uF; C_0402_1005Metric
C3, C8: 4.7uF; C_0402_1005Metric
C4: 10nF; C_0402_1005Metric
C4#2, C9, C10, C15: 0.1uF; C_0402_1005Metric
C6, C11, C12, C14: 100uF; C_0603_1608Metric
C7: 22uF; C_0402_1005Metric
D1, D2: SBDiode; SB Diode
D3, D4: MSS1P4-M3_89A; MICROSMP
D5: SDM20U40-7; SOD523
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: symbols_XF2M-1015-1A; XF2M-1015-1A
J2: U.FL-R-SMT-1
JP1: Jumper; Burn-Wire
L1: 22uH-LPS4018-223MR; LPS4018
L2: 10uH-LPS4018-103MR; LPS4018
Q1: IRLML2803; SOT-23
R1, R2, R3, R4, R8, R9, R10, R13, R14, R20, R21, R25: 0; R_0402_1005Metric
R5, R7: 1M; R_0402_1005Metric
R6: 4.7k; R_0402_1005Metric
R11: 4.75M; R_0402_1005Metric
R12, R18: 8.25M; R_0402_1005Metric
R15: 7.32M; R_0402_1005Metric
R16: 5.62M; R_0402_1005Metric
R17: 374K; R_0402_1005Metric
R19: 4.53M; R_0402_1005Metric
Ref**: Val**; ypanel
SC1, SC2, SC3, SC4, SC5, SC6, SC7, SC8: SolarCell_Small; KXOB25-05X3F
TP1, TP2, TP3, TP4, TP5: TP; TestPoint_THTPad_D1.0mm_Drill0.5mm
U1: TTB12G51-Balun; TTB12G51-balun
U2: NDS8434
U3: TSL2561
U4: Value; QFN50P350X350X100-21N-D

Connections:
+3V3: C1.1, C14.1, C15.1, D4.1, J1.6, R1.1, TP2.1, U3.1
/VBAT: C6.1, R25.2, U4.18
/VBURN: JP1.1, U2.5, U2.6, U2.7, U2.8
/coil: R3.1, R8.2, R9.1, R10.2
BATT_N: J1.2, R4.1
BATT_P: J1.1, R7.2, R25.1, TP4.1, U2.1, U2.2, U2.3
BURN1: J1.5, R6.2, TP5.1
COIL_N: J1.9, R9.2, R10.1
COIL_P: J1.10, R3.2, R8.1
GND: C1.2, C2.2, C3.2, C4.2, C4#2.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, D2.2, D5.A, J1.7, J1.8, J2.1, J2.2, JP1.2, Q1.2, R2.2, R4.2, R5.2, R11.1, R16.1, R19.1, R20.1, SC5.2, SC6.2, SC7.2, SC8.2, TP3.1, U1.2, U3.3, U4.1, U4.5, U4.9, U4.15, U4.17, U4.21
unnamed: C4.1, U4.4
unnamed: C7.1, C10.1, C12.1, D4.2, L2.2, U4.14
unnamed: C8.1, C9.1, C11.1, R14.1, U4.19
unnamed: D1.1, D3.2, SC1.1, SC2.1, SC3.1, SC4.1, TP1.1
unnamed: D1.2, D2.1, SC1.2, SC2.2, SC3.2, SC4.2, SC5.1, SC6.1, SC7.1, SC8.1
unnamed: H1.1, U1.3
unnamed: H2.1, U1.4
unnamed: J2.3, U1.1
unnamed: L1.2, U4.20
unnamed: L2.1, U4.16
unnamed: Q1.1, R5.1, R6.1
unnamed: Q1.3, R7.1, U2.4
unnamed: R1.2, R2.1, U3.2
unnamed: R11.2, R12.1, U4.12
unnamed: R12.2, R15.2, R17.2, U4.8
unnamed: R14.2, R20.2, R21.1, U4.3
unnamed: R15.1, R16.2, U4.7
unnamed: R17.1, R18.2, U4.10
unnamed: R18.1, R19.2, U4.11
SCL1: J1.4, U3.4
SDA1: J1.3, U3.6
VBAT_OK: R13.1, U4.13
VOUT_EN: C2.1, R13.2, U4.6
VSOLAR: C3.1, C4#2.1, D3.1, D5.C, L1.1, R21.2, U4.2

## Commit log

2019-12-16 Library edit battle and adding some silkscreen info.
2019-12-16 Massaged J1 into there somehow.
2019-12-16 Retracing.
2019-12-16 UFL added. Another footprint victory.
2019-12-16 Caught mistake on burnwire circuit.
2019-12-16 Trace correction.
2019-12-20 v01 order + repo update
2019-12-22 fixed unmanufacturable trace clearances and resubmitted order
2020-02-12 repaired schematic such that it matches pcb. repaired pcb such that design rules are met
2020-02-19 moved burnwire circuit and added slot for fishing twine tiedown
2020-02-20 updated 3d footprint paths and generated new step file
2020-02-28 Updated magnetorquer coils
2020-02-29 design review and generated gerbers
2020-03-01 fixed version number, regenerated gerbers and 3d model
2020-03-05 Fixed magnetorquer coils
2020-03-05 regenerated gerbers for fix with trace to edge clearence issue
